# Keil uVision project Ping-Pong.uvprojx, settings and files
target Ping-Pong-868-lora (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x14000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SX1261-RTxTest-Freq915-SF07-BW125 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L152xE USE_BAND_868 USE_MODEM_LORA IRQ_MODE REGION_EU868 SX1261DVK1BAS
  c include: ..\..\..\src;..\..\..\src\boards\NucleoL152;..\..\..\src\boards\NucleoL152\cmsis;..\..\..\src\boards\mcu\stm32;..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\inc;..\..\..\src\mac;..\..\..\src\peripherals;..\..\..\src\peripherals\ble;..\..\..\src\peripherals\display;..\..\..\src\radio;..\..\..\src\system;..\..\..\src\system\crypto;..\..\..\src\boards
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group apps
    ../../../src/apps/ping-pong/NucleoL152/: main.c
  group boards\NucleoL152
    ../../../src/boards/NucleoL152/: board.c gpio-board.c rtc-board.c spi-board.c uart-board.c sx1261dvk1bas-board.c delay-board.c
    ../../../src/boards/mcu/: utilities.c
  group boards\NucleoL152\cmsis
    ../../../src/boards/NucleoL152/cmsis/: system_stm32l1xx.c
    ../../../src/boards/NucleoL152/cmsis/arm-std/: startup_stm32l152xe.s
  group boards\NucleoL152\STM32L1xx_HAL_Driver
    ../../../src/boards/mcu/stm32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c
  group boards\mcu\stm32
    ../../../src/boards/mcu/stm32/: sysIrqHandlers.c
  group radio
    ../../../src/radio/sx126x/: sx126x.c radio.c
  group system
    ../../../src/system/: delay.c fifo.c gpio.c timer.c uart.c
target Ping-Pong-868-fsk (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: as above
  output: Ping-Pong +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L152xE USE_BAND_868 USE_MODEM_FSK IRQ_MODE
  c include: ..\..\..\src;..\..\..\src\boards\NucleoL152;..\..\..\src\boards\NucleoL152\cmsis;..\..\..\src\boards\mcu\stm32;..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\inc;..\..\..\src\mac;..\..\..\src\peripherals;..\..\..\src\radio;..\..\..\src\system;..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
target Ping-Pong-915-lora (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: as above
  output: Ping-Pong +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L152xE USE_BAND_915 USE_MODEM_LORA IRQ_MODE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
target Ping-Pong-915-fsk (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: as above
  output: Ping-Pong +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L152xE USE_BAND_915 USE_MODEM_FSK IRQ_MODE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
